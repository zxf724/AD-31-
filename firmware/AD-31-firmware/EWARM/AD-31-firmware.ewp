# IAR project AD-31-firmware.ewp, settings and files
configuration AD-31-firmware (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103C8 ST STM32F103C8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F103xB
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy; ../Middlewares/Third_Party/FreeRTOS/Source/include; ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS; ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM3; ../Drivers/CMSIS/Device/ST/STM32F1xx/Include; ../Drivers/CMSIS/Include; ..\M2M; ..\M2M\EC20; ..\M2M\BC26; ..\WIFI; ..\WIFI\ESP8266; ..\RTC; ..; ..\MQTT\FreeRTOS; ..\MQTT\MQTTPacket; ..\cJSON; ..\MQTT
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\\Inc
  OBJCOPY.OOCOutputFile: AD-31-firmware.hex
  ILINK.IlinkOutputFile: AD-31-firmware.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\ST\stm32f103x8.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ../Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/iar/: startup_stm32f103xb.s
  group Application/User
    ../Src/: console.c DataSave.c dfu.c freertos.c http.c main.c Param.c prjlib.c spi_flash.c stm32f1xx_hal_msp.c stm32f1xx_it.c system.c uart.c main.c freertos.c stm32f1xx_it.c stm32f1xx_hal_msp.c
    ../Inc/: user_comm.h
  group cJSON
    ../cJSON/: cJSON.c cJSON.h
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c system_stm32f1xx.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal_spi_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_spi.c stm32f1xx_hal_spi_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c
  group LAN
    ../LAN/: lan_conf.h
  group LAN/W5500/common
    ../LAN/w5500/common/: common.h md5.c md5.h util.c util.h
  group LAN/W5500/ethernet
    ../LAN/w5500/ethernet/: wizchip_conf.c wizchip_conf.h
  group LAN/W5500/ethernet/socket
    ../LAN/w5500/ethernet/socket/: netctrl.c netctrl.h socket.c socket.h sockutil.c sockutil.h
  group LAN/W5500/ethernet/socket_bsd
    ../LAN/w5500/ethernet/socket_bsd/: socket_bsd.c socket_bsd.h
  group LAN/W5500/ethernet/w5500
    ../LAN/w5500/ethernet/w5500/: w5500.c w5500.h
  group LAN/W5500/host
    ../LAN/w5500/host/: w5500_comm.c w5500_comm.h
  group LAN/W5500/initernet/DHCP
    ../LAN/w5500/internet/DHCP/: dhcp.c dhcp.h
  group LAN/W5500/initernet/DNS
    ../LAN/w5500/internet/DNS/: dns.c dns.h
  group M2M/BC26
    ../M2M/BC26/: M2M.c M2M.h
  group M2M/EC20
    ../M2M/EC20/: m2m.c m2m.h
    ../M2M/: m2m_cfg.h
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM3/: port.c portasm.s port.c portasm.s
  group MQTT
    ../MQTT/: MQTT_Conn.c mqtt_conn.h MQTTClient.c MQTTClient.h
  group MQTT/FreeRTOS
    ../MQTT/FreeRTOS/: MQTTFreeRTOS.c MQTTFreeRTOS.h
  group MQTT/MQTTPacket
    ../MQTT/MQTTPacket/: MQTTConnect.h MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTFormat.h MQTTPacket.c MQTTPacket.h MQTTPublish.h MQTTSerializePublish.c MQTTSubscribe.h MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribe.h MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c StackTrace.h
  group RTC
    ../RTC/: user_rtc.c user_rtc.h
  group WIFI/ESP8266
    ../WIFI/ESP8266/: wifi.c wifi.h

/*******************************************************************************
 * Copyright (c) 2014, 2015 IBM Corp.
 *
 * All rights reserved. This program and the accompanying materials
 * are made available under the terms of the Eclipse Public License v1.0
 * and Eclipse Distribution License v1.0 which accompany this distribution.
 *
 * The Eclipse Public License is available at
 *    http://www.eclipse.org/legal/epl-v10.html
 * and the Eclipse Distribution License is available at
 *   http://www.eclipse.org/org/documents/edl-v10.php.
 *
 * Contributors:
 *    Allan Stockdill-Mander/Ian Craggs - initial API and implementation and/or initial documentation
 *******************************************************************************/
#include "MQTTClient.h"
#include "user_comm.h"
#include "cJSON.H"
#include "datasave.h"
#include "time.h"
void  databasepack(char *cmd, cJSON *desired, char *buf){
    char *s = NULL;
    cJSON *root = NULL;
    root = cJSON_CreateObject();
    if (root != NULL) {
        char temp[12];
        memset(temp, 0x00, 12);
        //uitoa(HAL_GetTick(), temp);
        cJSON_AddNumberToObject(root, "messageid", HAL_GetTick());
        cJSON_AddNumberToObject(root, "timestamp", time((time_t *)NULL));
        cJSON_AddStringToObject(root, "cmd", cmd);
        cJSON_AddStringToObject(root, "deviceid", WorkParam.mqtt.MQTT_ClientID);
        cJSON_AddItemToObjectCS(root, "desired", desired);
        s = cJSON_PrintUnformatted(root);
        if (s != NULL) {
            strcpy(buf, s);
            MMEMORY_FREE(s);
        }
        cJSON_Delete(root);
    }
    else{
        cJSON_Delete(desired);      
    }
}
/**
* 登录处理
 * param “Connect”登录信息，“Heartbeat”心跳包
 */
int32_t log_in(char *buf){
    cJSON *root;
    root = cJSON_CreateObject();
    if (root != NULL) {
        cJSON_AddStringToObject(root, "version", VERSION);
        databasepack("CMD-01",root, buf);        
        DBG_LOG("[MQTT] log_in:%s",buf);
    }
    return strlen(buf);
}
/**
* 心跳处理
 * param “Connect”登录信息，“Heartbeat”心跳包
 */
int32_t heart(char *buf){
    cJSON *root;
    root = cJSON_CreateObject();
    if (root != NULL) {
        cJSON_AddNumberToObject(root, "heart", WorkParam.mqtt.MQTT_PingInvt);
        databasepack("CMD-02",root, buf);        
        DBG_LOG("[MQTT] heart:%s",buf);
    }
    return strlen(buf);
}

static void NewMessageData(MessageData *md, MQTTString *aTopicName, MQTTMessage *aMessage)
{
    md->topicName = aTopicName;
    md->message = aMessage;
}

static int getNextPacketId(MQTTClient *c)
{
    return c->next_packetid = (c->next_packetid == MAX_PACKET_ID) ? 1 : c->next_packetid + 1;
}

static int sendPacket(MQTTClient *c, int length, Timer *timer)
{
    int rc = FAILURE,
        sent = 0;
    DBG_LOG("c->buf:%*s,length:%d",length, c->buf ,length);
    while (sent < length && !TimerIsExpired(timer)) {

        rc = c->ipstack->mqttwrite(c->ipstack, &c->buf[sent], length - sent, TimerLeftMS(timer));
        if (rc < 0)  // there was an error writing the data
            break;
        sent += rc;
    }
    if (sent == length) {
        TimerCountdown(&c->ping_timer, c->keepAliveInterval / 2); // record the fact that we have successfully sent the packet
        rc = SUCESS;
    } else rc = FAILURE;
    return rc;
}

void MQTTClientInit(MQTTClient *c, Network *network, unsigned int command_timeout_ms,
                    unsigned char *sendbuf, size_t sendbuf_size, unsigned char *readbuf, size_t readbuf_size)
{
    int i;

    c->ipstack = network;

    for (i = 0; i < MAX_MESSAGE_HANDLERS; ++i) c->messageHandlers[i].topicFilter = 0;
    c->command_timeout_ms = command_timeout_ms;
    c->buf = sendbuf;
    c->buf_size = sendbuf_size;
    c->readbuf = readbuf;
    c->readbuf_size = readbuf_size;
    c->isconnected = 0;
    c->ping_outstanding = 0;
    c->defaultMessageHandler = NULL;
    c->next_packetid = 1;
    TimerInit(&c->ping_timer);
#if defined(MQTT_TASK)
    MutexInit(&c->mutex);
#endif
}
#if MQTT_TYPE == 0
static int decodePacket(MQTTClient *c, int *value, int timeout){
    unsigned char i;
    int multiplier = 1;
    int len = 0;
    const int MAX_NO_OF_REMAINING_LENGTH_BYTES = 4;

    *value = 0;
    do {
        int rc = MQTTPACKET_READ_ERROR;

        if (++len > MAX_NO_OF_REMAINING_LENGTH_BYTES) {
            rc = MQTTPACKET_READ_ERROR; /* bad data */
            goto exit;
        }
        rc = c->ipstack->mqttread(c->ipstack, &i, 1, timeout);
        if (rc != 1) goto exit;
        *value += (i & 127) * multiplier;
        multiplier *= 128;
    } while ((i & 128) != 0);
exit:
    return len;
}
#endif
static int readPacket(MQTTClient *c, Timer *timer){
#if MQTT_TYPE == 0
    int rc = FAILURE;
    MQTTHeader header = { 0 };
    int len = 0;
    int rem_len = 0;

    /* 1. read the header byte.  This has the packet type in it */
    if (c->ipstack->mqttread(c->ipstack, c->readbuf, 1, TimerLeftMS(timer)) != 1) goto exit;

    len = 1;
    /* 2. read the remaining length.  This is variable in itself */
    decodePacket(c, &rem_len, TimerLeftMS(timer));
    len += MQTTPacket_encode(c->readbuf + 1, rem_len); /* put the original remaining length back into the buffer */

    /* 3. read the rest of the buffer using a callback to supply the rest of the data */
    if (rem_len > 0 && (c->ipstack->mqttread(c->ipstack, c->readbuf + len, rem_len, TimerLeftMS(timer)) != rem_len)) goto exit;

    header.byte = c->readbuf[0];
    rc = header.bits.type;

exit:
    return rc;
#elif MQTT_TYPE == 1
    int rc = FAILURE;
    MQTTHeader header = { 0 };
    int len = 0;
    //int rem_len = 0;
    len = c->ipstack->mqttread(c->ipstack, c->readbuf, SOCKET_FIFO_SIZE, TimerLeftMS(timer)); //
    c->readbuf_size = len;
    if(len > 0){
        header.byte = PUBLISH << 4;
        rc = header.bits.type;
    }    
    return rc;
#endif
}
#if MQTT_TYPE == 0
// assume topic filter and name is in correct format
// # can only be at end
// + and # can only be next to separator
static char isTopicMatched(char *topicFilter, MQTTString *topicName)
{
    char *curf = topicFilter;
    char *curn = topicName->lenstring.data;
    char *curn_end = curn + topicName->lenstring.len;

    while (*curf && curn < curn_end) {
        if (*curn == '/' && *curf != '/') break;
        if (*curf != '+' && *curf != '#' && *curf != *curn) break;
        if (*curf == '+') {   // skip until we meet the next separator, or end of string
            char *nextpos = curn + 1;

            while (nextpos < curn_end && *nextpos != '/') nextpos = ++curn + 1;
        } else if (*curf == '#') curn = curn_end - 1;    // skip until end of string
        curf++;
        curn++;
    };

    return (curn == curn_end) && (*curf == '\0');
}
#endif

int deliverMessage(MQTTClient *c, MQTTString *topicName, MQTTMessage *message)
{
#if MQTT_TYPE == 0
    int i;
    int rc = FAILURE;

    // we have to find the right message handler - indexed by topic
    for (i = 0; i < MAX_MESSAGE_HANDLERS; ++i) {
        if (c->messageHandlers[i].topicFilter != 0 && (MQTTPacket_equals(topicName, (char *)c->messageHandlers[i].topicFilter) ||
            isTopicMatched((char *)c->messageHandlers[i].topicFilter, topicName))) {
            if (c->messageHandlers[i].fp != NULL) {
                MessageData md;
                NewMessageData(&md, topicName, message);
                c->messageHandlers[i].fp(&md);
                rc = SUCESS;
            }
        }
    }
    if (rc == FAILURE && c->defaultMessageHandler != NULL) {
        MessageData md;
        NewMessageData(&md, topicName, message);
        c->defaultMessageHandler(&md);
        rc = SUCESS;
    }

    return rc;
#elif MQTT_TYPE == 1
    int i;
    int rc = FAILURE;
    // we have to find the right message handler - indexed by topic
    for (i = 0; i < MAX_MESSAGE_HANDLERS; ++i) {
        if (c->messageHandlers[i].fp != NULL) {
            MessageData md;
            NewMessageData(&md, topicName, message);
            //DBG_LOG("NewMessageData :%s",md.message->payload);
            c->messageHandlers[i].fp(&md);
            rc = SUCESS;
        }
    }
    return rc;
#endif
}

int keepalive(MQTTClient *c)
{
#if MQTT_TYPE == 0
    int rc = FAILURE;

    if (c->keepAliveInterval == 0) {
        rc = SUCESS;
        goto exit;
    }
    
    if (TimerIsExpired(&c->ping_timer)) {
        if (!c->ping_outstanding) {
            Timer timer;
            TimerInit(&timer);
            TimerCountdownMS(&timer, 1000);
            int len = MQTTSerialize_pingreq(c->buf, c->buf_size);

            if (len > 0 && (rc = sendPacket(c, len, &timer)) == SUCESS) // send the ping packet
                c->ping_outstanding = 1;
        }
    }

exit:
    return rc;
#elif MQTT_TYPE == 1
    int rc = FAILURE;

    if (c->keepAliveInterval == 0) {
        rc = SUCESS;
        goto exit;
    }
    DBG_LOG("ping_timer:%u \r,c->ping_outstanding");
    if (TimerIsExpired(&c->ping_timer)){
        if (!c->ping_outstanding) {
            Timer timer;
            TimerInit(&timer);
            TimerCountdownMS(&timer, 1000);
            //Publish_ConnectHeart("");
            //int len = MQTTSerialize_pingreq(c->buf, c->buf_size);
            int len = heart((char*)c->buf);
            if (len > 0 && (rc = sendPacket(c, len, &timer)) == SUCESS) // send the ping packet
                c->ping_outstanding = 1;
        }
    }

    exit:
return rc;
#endif
}
void MQTTCleanSession(MQTTClient* c)
{
    int i = 0;
    for (i = 0; i < MAX_MESSAGE_HANDLERS; ++i)
        c->messageHandlers[i].topicFilter = NULL;
}
void MQTTCloseSession(MQTTClient* c)
{
    c->ping_outstanding = 0;
    c->isconnected = 0;
    if (c->cleansession)
        MQTTCleanSession(c);
}

//extern void ArrivePath(uint8_t *dat, uint16_t len);
int cycle(MQTTClient *c, Timer *timer)
{
    // read the socket, see what work is due
#if MQTT_TYPE == 0
    unsigned short packet_type = readPacket(c, timer); //

    int len = 0, rc = SUCESS;
    switch (packet_type) {
    case CONNACK:
    case PUBACK:
    case SUBACK:
        break;
    case PUBLISH:
        {
            MQTTString topicName;
            MQTTMessage msg;
            int intQoS;

            if (MQTTDeserialize_publish(&msg.dup, &intQoS, &msg.retained, &msg.id, &topicName,
                                        (unsigned char **)&msg.payload, (int *)&msg.payloadlen, c->readbuf, c->readbuf_size) != 1) goto exit;
            msg.qos = (enum QoS)intQoS;
            deliverMessage(c, &topicName, &msg);
            if (msg.qos != QOS0) {
                if (msg.qos == QOS1) len = MQTTSerialize_ack(c->buf, c->buf_size, PUBACK, 0, msg.id);
                else if (msg.qos == QOS2) len = MQTTSerialize_ack(c->buf, c->buf_size, PUBREC, 0, msg.id);
                if (len <= 0) {
                    rc = FAILURE;
                } else {
                    rc = sendPacket(c, len, timer);
                }
                if (rc == FAILURE) goto exit; // there was a problem
            }
            break;
        }
    case PUBREC:
        {
            unsigned short mypacketid;
            unsigned char dup, type;

            if (MQTTDeserialize_ack(&type, &dup, &mypacketid, c->readbuf, c->readbuf_size) != 1) rc = FAILURE;
            else if ((len = MQTTSerialize_ack(c->buf, c->buf_size, PUBREL, 0, mypacketid)) <= 0) rc = FAILURE;
            else if ((rc = sendPacket(c, len, timer)) != SUCESS) // send the PUBREL packet
                rc = FAILURE; // there was a problem
            if (rc == FAILURE) goto exit; // there was a problem
            break;
        }
    case PUBCOMP:
        break;
    case UNSUBACK:
        break;
    case PINGRESP:
        c->ping_outstanding = 0;
        break;
    default:
        break;
    }
    keepalive(c);
exit:
    if (rc == SUCESS) rc = packet_type;
    else if (c->isconnected)
        MQTTCloseSession(c);
    return rc;
#elif MQTT_TYPE == 1
    unsigned short packet_type = readPacket(c, timer); //
    int rc = SUCESS;
    switch (packet_type) {
    case CONNACK:
    case PUBACK:
    case SUBACK:
    case PUBLISH:
        {
            MQTTString topicName;
            MQTTMessage msg;
            int intQoS;
            if (MQTTDeserialize_publish(&msg.dup, &intQoS, &msg.retained, &msg.id, &topicName,
                                        (unsigned char **)&msg.payload, (int *)&msg.payloadlen, c->readbuf, c->readbuf_size) != 1) goto exit;

            deliverMessage(c, &topicName, &msg);
            rc = SUCESS;
            c->ping_outstanding = 0;
            break;
        }
    case PUBREC:
        break;
    case PUBCOMP:
        break;
    case UNSUBACK:
        break;
    case PINGRESP:
        c->ping_outstanding = 0;
        break;
    default:
        rc = FAILURE;
        break;
    }
    keepalive(c);
exit:
    if (rc == SUCESS) rc = packet_type;
    return rc;
#endif
}

int MQTTYield(MQTTClient *c, int timeout_ms)
{
    int rc = SUCESS;
    Timer timer;
    
    TimerInit(&timer);
    TimerCountdownMS(&timer, timeout_ms);
    DBG_LOG("MQTTYield\r");
    do {
        if (cycle(c, &timer) == FAILURE) {
            rc = FAILURE;
            break;
        }
    } while (!TimerIsExpired(&timer));

    return rc;
}

void MQTTRun(void *parm)
{
    Timer timer;
    MQTTClient *c = (MQTTClient *)parm;

    TWDT_DEF(mqttTask, 60000);
    TWDT_ADD(mqttTask);
    TWDT_CLEAR(mqttTask);

    TimerInit(&timer);

    DBG_LOG("MQTT task start.");
    while (1) {
#if defined(MQTT_TASK)
        MutexLock(&c->mutex);
#endif
        TimerCountdownMS(&timer, 10); /* Don't wait too long if no traffic is incoming */
        cycle(c, &timer);
#if defined(MQTT_TASK)
        MutexUnlock(&c->mutex);
#endif
        TWDT_CLEAR(mqttTask);
        osDelay(2);

        /*jonas 2016.9.3*/
        //Manager_MQTT();
    }
}


#if defined(MQTT_TASK) //?开?MQTT任�??

int MQTTStartTask(MQTTClient *client)
{
    return ThreadStart(&client->thread, &MQTTRun, client);
}
#endif

int waitfor(MQTTClient *c, int packet_type, Timer *timer)
{
     
    int rc = FAILURE;
    do {
        DBG_LOG("waitfor\r");
        if (TimerIsExpired(timer)) break; // we timed out
    }while ((rc = cycle(c, timer)) != packet_type);
    return rc;
}

int MQTTConnect(MQTTClient *c, MQTTPacket_connectData *options){
#if MQTT_TYPE == 0
    Timer connect_timer;
    int rc = FAILURE;
    MQTTPacket_connectData default_options = MQTTPacket_connectData_initializer;
    int len = 0;

    #if defined(MQTT_TASK)

    MutexLock(&c->mutex);
    #endif
    if (c->isconnected) /* don't send connect packet again if we are already connected */
        goto exit;

    TimerInit(&connect_timer);
    TimerCountdownMS(&connect_timer, c->command_timeout_ms);

    if (options == 0) options = &default_options; /* set default options if none were supplied */

    c->keepAliveInterval = options->keepAliveInterval;

    TimerCountdown(&c->ping_timer, c->keepAliveInterval);
    if ((len = MQTTSerialize_connect(c->buf, c->buf_size, options)) <= 0) goto exit;
    if ((rc = sendPacket(c, len, &connect_timer)) != SUCESS)  // send the connect packet//
        goto exit; // there was a problem

    // this will be a blocking call, wait for the connack
    if (waitfor(c, CONNACK, &connect_timer) == CONNACK) {
        unsigned char connack_rc = 255;
        unsigned char sessionPresent = 0;

        if (MQTTDeserialize_connack(&sessionPresent, &connack_rc, c->readbuf, c->readbuf_size) == 1) rc = connack_rc;
        else rc = FAILURE;
    } else rc = FAILURE;

exit:
    if (rc == SUCESS) c->isconnected = 1;

    #if defined(MQTT_TASK)
    MutexUnlock(&c->mutex);
    #endif
    return rc;
#elif MQTT_TYPE == 1
    Timer connect_timer;
    int rc = FAILURE;
    MQTTPacket_connectData default_options = MQTTPacket_connectData_initializer;
    int len = 0;
    #if defined(MQTT_TASK)
    MutexLock(&c->mutex);
    #endif
    if (c->isconnected) /* don't send connect packet again if we are already connected */
        goto exit;
    TimerInit(&connect_timer);
    TimerCountdownMS(&connect_timer, c->command_timeout_ms);
    if (options == 0) options = &default_options; /* set default options if none were supplied */

    c->keepAliveInterval = options->keepAliveInterval;
    TimerCountdown(&c->ping_timer, c->keepAliveInterval);
    len = log_in((char*)c->buf);
    //if ((len = MQTTSerialize_connect(c->buf, c->buf_size, options)) <= 0) goto exit;
    if ((rc = sendPacket(c, len, &connect_timer)) != SUCESS || len == 0)  // send the connect packet//
        goto exit; // there was a problem

    // this will be a blocking call, wait for the connack
    if (waitfor(c, CONNACK, &connect_timer) == CONNACK) {
        //unsigned char connack_rc = 255;
        //unsigned char sessionPresent = 0;
        //if (MQTTDeserialize_connack(&sessionPresent, &connack_rc, c->readbuf, c->readbuf_size) == 1) rc = connack_rc;
        //else rc = FAILURE;
        rc = SUCESS;
    } else{
        rc = FAILURE;        
    }

exit:
    if (rc == SUCESS) {
        c->isconnected = 1;
    }
    else{
        MQTTCloseSession(c);
    }
    #if defined(MQTT_TASK)
    MutexUnlock(&c->mutex);
    #endif
    return rc;
#endif
}
int MQTTSetMessageHandler(MQTTClient* c, const char* topicFilter, messageHandler messageHandler)
{
    int rc = FAILURE;
    int i = -1;

    /* first check for an existing matching slot */
    for (i = 0; i < MAX_MESSAGE_HANDLERS; ++i)
    {
        if (c->messageHandlers[i].topicFilter != NULL && strcmp(c->messageHandlers[i].topicFilter, topicFilter) == 0)
        {
            if (messageHandler == NULL) /* remove existing */
            {
                c->messageHandlers[i].topicFilter = NULL;
                c->messageHandlers[i].fp = NULL;
            }
            rc = SUCCESS; /* return i when adding new subscription */
            break;
        }
    }
    /* if no existing, look for empty slot (unless we are removing) */
    if (messageHandler != NULL) {
        if (rc == FAILURE)
        {
            for (i = 0; i < MAX_MESSAGE_HANDLERS; ++i)
            {
                if (c->messageHandlers[i].topicFilter == NULL)
                {
                    rc = SUCCESS;
                    break;
                }
            }
        }
        if (i < MAX_MESSAGE_HANDLERS)
        {
            c->messageHandlers[i].topicFilter = topicFilter;
            c->messageHandlers[i].fp = messageHandler;
        }
    }
    return rc;
}
int MQTTSubscribeWithResults(MQTTClient* c, const char* topicFilter, enum QoS qos,
       messageHandler messageHandler, MQTTSubackData* data)
{
    int rc = FAILURE;
    Timer timer;
    int len = 0;
    MQTTString topic = MQTTString_initializer;
    topic.cstring = (char *)topicFilter;

#if defined(MQTT_TASK)
	  MutexLock(&c->mutex);
#endif
	  if (!c->isconnected)
		    goto exit;

    TimerInit(&timer);
    TimerCountdownMS(&timer, c->command_timeout_ms);

    len = MQTTSerialize_subscribe(c->buf, c->buf_size, 0, getNextPacketId(c), 1, &topic, (int*)&qos);
    if (len <= 0)
        goto exit;
    if ((rc = sendPacket(c, len, &timer)) != SUCCESS) // send the subscribe packet
        goto exit;             // there was a problem

    if (waitfor(c, SUBACK, &timer) == SUBACK)      // wait for suback
    {
        int count = 0;
        unsigned short mypacketid;
        data->grantedQoS = QOS0;
        if (MQTTDeserialize_suback(&mypacketid, 1, &count, (int*)&data->grantedQoS, c->readbuf, c->readbuf_size) == 1)
        {
            if (data->grantedQoS != 0x80)
                rc = MQTTSetMessageHandler(c, topicFilter, messageHandler);
        }
    }
    else
        rc = FAILURE;

exit:
    if (rc == FAILURE)
        MQTTCloseSession(c);
#if defined(MQTT_TASK)
	  MutexUnlock(&c->mutex);
#endif
    return rc;
}
int MQTTSubscribe(MQTTClient *c, const char *topicFilter, enum QoS qos, messageHandler messageHandler)
{
   
   

#if MQTT_TYPE == 0
    MQTTSubackData data;
    return MQTTSubscribeWithResults(c, topicFilter, qos, messageHandler, &data);
#elif MQTT_TYPE == 1
    int rc = FAILURE;
    Timer timer;
    //int len = 0;
    //MQTTString topic = MQTTString_initializer;

    //topic.cstring = (char *)topicFilter;

    #if defined(MQTT_TASK)
    MutexLock(&c->mutex);
    #endif
    if (!c->isconnected) goto exit;

    TimerInit(&timer);
    TimerCountdownMS(&timer, c->command_timeout_ms);
    int i;
    for (i = 0; i < MAX_MESSAGE_HANDLERS; ++i) {
        if (c->messageHandlers[i].topicFilter == 0) {
            c->messageHandlers[i].topicFilter = topicFilter;
            c->messageHandlers[i].fp = messageHandler;
            rc = SUCESS;
            break;
        }
    }
    exit:
#if defined(MQTT_TASK)
    MutexUnlock(&c->mutex);
#endif
    return rc;
#endif

}

int MQTTUnsubscribe(MQTTClient *c, const char *topicFilter){
    int rc = FAILURE;
    Timer timer;
    MQTTString topic = MQTTString_initializer;

    topic.cstring = (char *)topicFilter;
    int len = 0;

#if defined(MQTT_TASK)

    MutexLock(&c->mutex);
#endif
    if (!c->isconnected) goto exit;

    TimerInit(&timer);
    TimerCountdownMS(&timer, c->command_timeout_ms);

    if ((len = MQTTSerialize_unsubscribe(c->buf, c->buf_size, 0, getNextPacketId(c), 1, &topic)) <= 0) goto exit;
    if ((rc = sendPacket(c, len, &timer)) != SUCESS) // send the subscribe packet
        goto exit; // there was a problem

    if (waitfor(c, UNSUBACK, &timer) == UNSUBACK) {
        unsigned short mypacketid;  // should be the same as the packetid above

        if (MQTTDeserialize_unsuback(&mypacketid, c->readbuf, c->readbuf_size) == 1) rc = 0;
    } else rc = FAILURE;

exit:
#if defined(MQTT_TASK)
    MutexUnlock(&c->mutex);
#endif
    if (rc == FAILURE)
        MQTTCloseSession(c);
    return rc;
}

int MQTTPublish(MQTTClient *c, const char *topicName, MQTTMessage *message)
{
    #if MQTT_TYPE == 0
    int rc = FAILURE;
    Timer timer;
    MQTTString topic = MQTTString_initializer;

    topic.cstring = (char *)topicName;
    int len = 0;

#if defined(MQTT_TASK)
    MutexLock(&c->mutex);
#endif
    if (!c->isconnected) goto exit;

    TimerInit(&timer);
    TimerCountdownMS(&timer, c->command_timeout_ms);

    if (message->qos == QOS1 || message->qos == QOS2) message->id = getNextPacketId(c);

    len = MQTTSerialize_publish(c->buf, c->buf_size, 0, message->qos, message->retained, message->id,
                                topic, (unsigned char *)message->payload, message->payloadlen);
    if (len <= 0) goto exit;
    if ((rc = sendPacket(c, len, &timer)) != SUCESS) // send the subscribe packet
        goto exit; // there was a problem
    if (message->qos == QOS1) {
        if (waitfor(c, PUBACK, &timer) == PUBACK) {
            unsigned short mypacketid;
            unsigned char dup, type;
            if (MQTTDeserialize_ack(&type, &dup, &mypacketid, c->readbuf, c->readbuf_size) != 1) rc = FAILURE;
        } else rc = FAILURE;
    } else if (message->qos == QOS2) {
        if (waitfor(c, PUBCOMP, &timer) == PUBCOMP) {
            unsigned short mypacketid;
            unsigned char dup, type;

            if (MQTTDeserialize_ack(&type, &dup, &mypacketid, c->readbuf, c->readbuf_size) != 1) rc = FAILURE;
        } else rc = FAILURE;
    }

exit:
#if defined(MQTT_TASK)
    MutexUnlock(&c->mutex);
#endif
    if (rc == FAILURE)
        MQTTCloseSession(c);
    return rc;
#elif MQTT_TYPE == 1
    int rc = FAILURE;
    Timer timer;
    //MQTTString topic = MQTTString_initializer;
    //topic.cstring = (char *)topicName;
    int len = 0;
    #if defined(MQTT_TASK)
    MutexLock(&c->mutex);
    #endif
    if (!c->isconnected) goto exit;
    TimerInit(&timer);
    TimerCountdownMS(&timer, c->command_timeout_ms);
    //len = MQTTSerialize_publish(c->buf, c->buf_size, 0, message->qos, message->retained, message->id,
                                //topic, (unsigned char *)message->payload, message->payloadlen);

    memcpy(c->buf, message->payload, message->payloadlen);
    len = message->payloadlen;
    //DBG_LOG("c->buf:%*s,payloadlen:%d",len,c->buf ,len);
    //DBG_LOG("messag  e->payload:%s,payloadlen:%d",c->buf ,message->payloadlen);
    if (len <= 0) goto exit;
    if ((rc = sendPacket(c, len, &timer)) != SUCESS) // send the subscribe packet
        goto exit; // there was a problem
    exit:
    #if defined(MQTT_TASK)
    MutexUnlock(&c->mutex);
    #endif
    if (rc == FAILURE)
        MQTTCloseSession(c);
    return rc;
#endif
}

int MQTTDisconnect(MQTTClient *c)
{
    int rc = FAILURE;
    Timer timer;     // we might wait for incomplete incoming publishes to complete
    int len = 0;

#if defined(MQTT_TASK)

    MutexLock(&c->mutex);
#endif
    TimerInit(&timer);
    TimerCountdownMS(&timer, c->command_timeout_ms);

    len = MQTTSerialize_disconnect(c->buf, c->buf_size);
    if (len > 0) rc = sendPacket(c, len, &timer);            // send the disconnect packet

    MQTTCloseSession(c);

#if defined(MQTT_TASK)
    MutexUnlock(&c->mutex);
#endif
    return rc;
}
